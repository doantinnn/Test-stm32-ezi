# IAR project eziservo_ioboard.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F767xx
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Library\00_User; ..\Library\00_User\Ethernet; ..\Library\01_CMSIS\Include; ..\Library\01_CMSIS\Device\ST\STM32F7xx\Include; ..\Library\02_HalDriver\STM32F7xx_HAL_Driver\Inc; ..\Library\04_ThirdParty\LwIP\src\include; ..\Library\04_ThirdParty\LwIP\system; ..\Library\04_ThirdParty\LwIP\src\include\ipv4; ..\Library\04_ThirdParty\LwIP\src\include\netif
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: eziservo_ioboard.bin
  postbuild: ielftool --bin "$TARGET_PATH$" "$TARGET_DIR$\$TARGET_BNAME$.bin"
  ILINK.IlinkOutputFile: eziservo_ioboard.out
  ILINK.IlinkIcfFile: stm32f767xx_flash.icf
  group Application/User
    ../Library/00_User/Ethernet/: ethernetif.c
    ../Core/Src/: ezi_servo_driver.c IO_Board.c main.c CmdSet_Function.c CmdSet_Process.c Cmd_Motor.c Cmd_System.c Cmd_IO.c UI_Server.c
    ../Library/00_User/: stm32f7xx_it.c
  group Drivers/CMSIS
    ../Library/01_CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f767xx.s
    ../Library/01_CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Library/02_HalDriver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
  group Middlewares/LwIP
    ../Library/04_ThirdParty/LwIP/src/core/: def.c init.c inet_chksum.c lwip_timers.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../Library/04_ThirdParty/LwIP/src/core/ipv4/: autoip.c dhcp.c icmp.c igmp.c ip4.c ip4_addr.c ip_frag.c
    ../Library/04_ThirdParty/LwIP/src/netif/: etharp.c
